require pappl.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "78699769ac43921fd7c0003da2c3678c"
SRC_URI[sha256sum] = "c3d8febb56367940dd4c26e794fc5014abe8cd6ff0a63d1ce9e2c9089ce361c5"
