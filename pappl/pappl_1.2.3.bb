require pappl.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "7a9920fc52e7244fa875a35f046f885b"
SRC_URI[sha256sum] = "19a2bebe7ceb0223aa2400b6f28f38cc066cdfafbdaf4b87f678911644fd568e"
