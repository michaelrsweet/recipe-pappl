require pappl.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "8c8a49f15865acdc82dbaaee8fed035d"
SRC_URI[sha256sum] = "645d8da6ee288febbadc83a92c235af4e13ed6a7e6ec6d1a79badd91ac3178a2"
