require pappl.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[md5sum] = "f03f919660fcdb094c834878025a3d1b"
SRC_URI[sha256sum] = "93b2fd7f8d4528fa655adc6174ed7eb925e80f417663acd8118fb04b61cc38d7"
